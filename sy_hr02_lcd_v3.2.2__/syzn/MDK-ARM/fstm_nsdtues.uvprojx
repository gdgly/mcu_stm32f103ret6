# Keil uVision project fstm_nsdtues.uvprojx, settings and files
target fstm_nsdtues (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: fstm_nsdtues +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c misc: --C99
  c include: ../Drivers/STM32F1xx_HAL_Driver/Inc;                                                                                                                ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;                                                                                                                ../Drivers/CMSIS/Include;                                                                                                                ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;                                                                                                              ../../common/Inc;                                                                          ../Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_rcc.c stm32f1xx_hal_cortex.c stm32f1xx_hal_uart.c stm32f1xx_hal_pwr.c stm32f1xx_hal_dma.c stm32f1xx_hal.c stm32f1xx_hal_gpio.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_flash.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c
  group SerialDatagramTasks
    ../Src/: thread_of_LCM_uart.c thread_hc05.c thread_of_iot_uart.c thread_of_accelnet.c
  group SerialDatagramBase
    ../../common/Src/: misc.c uart-API.c uart-line-IO.c
  group SerialDeviceBase
    ../Src/: HC05.c bsp_eeprom.c
  group Application/User
    ../Src/: main.c stm32f1xx_it.c stm32f1xx_hal_msp.c
software components: CMSIS:CORE 4.3.0, CMSIS:RTOS:Keil RTX 4.80.0, Device:Startup 1.0.0
